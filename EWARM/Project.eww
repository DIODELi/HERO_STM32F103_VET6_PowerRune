<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HERO_STM32F103_VET6_BuffLED.ewp</path>
  </project>
  <batchBuild />
</workspace>
